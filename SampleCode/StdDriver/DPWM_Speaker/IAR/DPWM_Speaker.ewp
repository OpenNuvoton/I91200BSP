# IAR project DPWM_Speaker.ewp, settings and files
configuration I91200 (ARM, debug)
  General.OGChipSelectEditMenu: I91200 series Nuvoton I91200 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG_ENABLE_SEMIHOST; __I91200__
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\Include; ..\..\..\..\Library\Device\Nuvoton\I91200\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DPWM_Speaker.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: DPWM_Speaker.icf
  ILINK.IlinkExtraOptions: --image_input=..\Audio.bin,u32audioBegin,BIN_START,4; --image_input=..\Audio.bin,u32audioEnd,BIN_END,4
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration I91200BS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG_ENABLE_SEMIHOST; __I91200BS__
  group CMSIS
    ./: startup_I91200.s
    ../../../../Library/Device/Nuvoton/I91200/Source/: system_I91200.c
  group Library
    ../../../../Library/StdDriver/src/: biq.c clk.c dpwm.c retarget.c sys.c
  group User
    ../: main.c
    ../VDPWM/: VDPWM.c VDPWM.h
