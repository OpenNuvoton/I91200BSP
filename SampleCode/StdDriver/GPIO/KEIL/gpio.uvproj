# Keil uVision project gpio.uvproj, settings and files
target I91200 (ARM-ADS)
  device: I91260 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x1FFFF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: TIMER
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG_ENABLE_SEMIHOST, __I91200__
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\Include;..\..\..\..\Library\StdDriver\inc;..\VTIMER
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='startup_I91200.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./: startup_I91200.s
    ../../../../Library/Device/Nuvoton/I91200/Source/: system_I91200.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c gpio.c
target I91200BS (ARM-ADS)
  device: I91260 Nuvoton
  cpu: as above
  output: TIMER
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG_ENABLE_SEMIHOST, __I91200BS__
  c include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: as above
