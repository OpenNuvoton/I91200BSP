# Keil uVision project ISP_UART.uvproj, settings and files
target I91200 (ARM-ADS)
  device: I91260 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x233FF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: I91200_ISP_UART0_PA4_PA5
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\I91200\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\Include;..\..\..\..\Library\Device\Nuvoton\IDS9200\Include;..\VUART
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='startup_I91200.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../Library/Device/Nuvoton/I91200/Source/: system_I91200.c
    ../: startup_I91200.s
  group User
    ../: main.c FMC_USER.c ISP_USER.c targetdev.c uart_transfer.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c retarget.c uart.c
target I91200BS (ARM-ADS)
  device: I91260 Nuvoton
  cpu: as above
  output: I91200_ISP_UART0_PA4_PA5
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __I91200BS__
  c include: as above
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: as above
