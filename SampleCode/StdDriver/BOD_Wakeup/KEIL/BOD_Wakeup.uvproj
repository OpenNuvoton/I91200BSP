# Keil uVision project BOD_Wakeup.uvproj, settings and files
target I91200 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: I91260 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x1FFFF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: BOD_wakeup
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __I91200__
  c include: ..\..\..\..\Library\Device\Nuvoton\I91200\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='startup_I91200.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/I91200/Source/: system_I91200.c
    ./: startup_I91200.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: CLK.c retarget.c SYS.c uart.c gpio.c bod.c
target I91200BS (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: I91260 Nuvoton
  cpu: as above
  output: BOD_Wakeup
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __I91200BS__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: as above
