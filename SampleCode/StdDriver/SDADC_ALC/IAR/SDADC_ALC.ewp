# IAR project SDADC_ALC.ewp, settings and files
configuration I91200BS (ARM)
  General.OGChipSelectEditMenu: I91200 series Nuvoton I91200 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG_ENABLE_SEMIHOST; __I91200BS__
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\Include; ..\..\..\..\Library\Device\Nuvoton\I91200\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SDADC_ALC.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration I91200 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG_ENABLE_SEMIHOST; __I91200__
  group CMSIS
    ./: startup_I91200.s
    ../../../../Library/Device/Nuvoton/I91200/Source/: system_I91200.c
  group Library
    ../../../../Library/StdDriver/src/: biq.c clk.c dpwm.c gpio.c retarget.c sdadc.c sys.c uart.c
  group User
    ../: main.c
